# IAR project Backup of wirelessWB.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 180
  General.GHeapSize2: 180
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: CalFromTab.c CalFromTab.h CommDo.c CommDo.h DefineSPC.h DispDataDo.c DispDataDo.h FlashWR.c FlashWR.h InitSys.c InitSys.h InputDo.c InputDo.h Key.c Key.h LcdDriver.c LcdDriver.h main.c Predefined.h
